Commit message: sim works now.

File: drake/manipulation/models/irb120/urdf/irb120_3_58.urdf (robot description, URDF)
Before this commit: robot abb_irb120_3_58, 9 links, 8 joints
Links:
- link link_5: mass 0.546 -> .546
- link link_6: mass 0.137 -> .137
